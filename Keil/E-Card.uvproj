# Keil uVision project E-Card.uvproj, settings and files
target E-Card (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: E-Card +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./Src/: Main.c Main.h
  group LCD12864
    ./Src/: LCD12864.c LCD12864.h LCD12864_IMG.h
  group Key
    ./Src/: Key.c Key.h
  group Music
    ./Src/: Music.c Music.h MusicOpern.h
